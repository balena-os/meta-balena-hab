IMAGE_ROOTFS_MAXSIZE = "61440"
